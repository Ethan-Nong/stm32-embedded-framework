# Keil uVision project core_f407_seed_dev.uvprojx, settings and files
target core_f407_seed_dev (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: core_f407_seed_dev +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PROJECT_DS211_DEMO=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../..;../../overrides;../../../../shared/board;../../../../shared/bsp/include;../../../../shared/common/include;../../../../app/main;../../../../projects/core_f407_seed_dev;../../../../app/ds211_demo;../../../../shared/drivers/ds211;../../../../shared/drivers/ds211/include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../../../../app/main/: app_main.c
    ../../../../shared/board/: board.c
    ../../../../app/ds211_demo/: app_ds211_demo.c
    ../../../../shared/bsp/port/: bsp_adc_dma_port.c bsp_adc_port.c bsp_exti_port.c bsp_gpio_port.c bsp_i2c_port.c bsp_pwm_port.c bsp_sai_dma_port.c bsp_soft_i2c_port.c bsp_spi_port.c bsp_tick_port.c bsp_timer_port.c bsp_uart_port.c
    ../../../../shared/drivers/ds211/src/: drv_ds211.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
